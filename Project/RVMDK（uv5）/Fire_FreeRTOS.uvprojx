# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=3 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\key;..\..\User\uart;..\..\FreeModbus\modbus\ascii;..\..\FreeModbus\modbus\functions;..\..\FreeModbus\modbus\include;..\..\FreeModbus\modbus\rtu;..\..\FreeModbus\modbus\tcp;..\..\FreeModbus\port;..\..\User\i2c;..\..\User\lcd;..\..\User\i2c;..\..\User\relay;..\..\User\iwdg;..\..\User\flash;..\..\User\Modbus;..\..\User\nsa2862
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
    ../../User/Led/: bsp_led.c
    ../../User/uart/: bsp_usart.c
    ../../User/key/: bsp_key.c
    ../../User/i2c/: bsp_i2c.c sht20.c bsp_i2c_gpio.c
    ../../User/lcd/: bsp_lcd.c driver_ht1621.c
    ../../User/relay/: relay.c
    ../../User/iwdg/: bsp_iwdg.c
    ../../User/Modbus/: Modbus.c
    ../../User/nsa2862/: bsp_nsa2862.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group FreeModBus
    ../../FreeModbus/modbus/: mb.c
    ../../FreeModbus/modbus/ascii/: mbascii.c
    ../../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../../FreeModbus/modbus/tcp/: mbtcp.c
  group FreeModBus_Port
    ../../FreeModbus/port/: portevent.c portserial.c porttimer.c
  group DOC
    ../../Doc/: readme.txt
